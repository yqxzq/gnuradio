options:
  parameters:
    generate_options: qt_gui
    id: channel
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: ldec_H
  id: variable_ldpc_H_matrix_def
  parameters:
    filename: /usr/share/gnuradio/fec/ldpc/n_1800_k_0902_gap_28.alist
    gap: '28'
  states: {}
- name: ldpc_enc_H
  id: variable_ldpc_encoder_H_def
  parameters:
    H: ldec_H
    ndim: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: 0.5e6
    stop: 10e6
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_ldpc_decoder_def_0
  id: variable_ldpc_decoder_def
  parameters:
    file: /usr/share/gnuradio/fec/ldpc/n_1800_k_0902_gap_28.alist
    max_iter: '50'
    ndim: '0'
    sigma: '0.5'
  states: {}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/opensourcesdr/Desktop/th.jfif
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_key
    packet_len: '100'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: len_key
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 185.18e3*4
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: 185.18e3
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_1_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpacked_to_packed_xx_0_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.25'
    samples_per_symbol: '4'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: digital.header_format_default(access_key, 0)
    len_tag_key: len_key
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: ldpc_enc_H
    puncpat: '11'
    threadtype: none
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0000000000000000f77c60dc27658bc3
    bb_gain0: '0'
    freq0: 2.4e9
    gain0: '0'
    if_gain0: '30'
    sample_rate: 2e6
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"qpsk"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"final stream"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"tag"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"qpsk"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '3'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: '0'
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: input
  states: {}

connections:
- [blocks_char_to_float_0_1_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_1_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0_1_0, '0']
- [blocks_file_source_0, '0', virtual_sink_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_char_to_float_0_1_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_char_to_float_0_1_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_unpack_k_bits_bb_0_1_0, '0', fec_extended_encoder_0, '0']
- [blocks_unpacked_to_packed_xx_0_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_constellation_modulator_0, '0', osmosdr_sink_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_1, '0']
- [digital_constellation_modulator_0, '0', uhd_usrp_sink_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [fec_extended_encoder_0, '0', blocks_unpacked_to_packed_xx_0_1, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
