options:
  parameters:
    generate_options: qt_gui
    id: channel
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: a
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '64'
  states: {}
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: ldec_H
  id: variable_ldpc_H_matrix_def
  parameters:
    filename: /usr/share/gnuradio/fec/ldpc/n_1800_k_0902_gap_28.alist
    gap: '28'
  states: {}
- name: ldpc_enc_H
  id: variable_ldpc_encoder_H_def
  parameters:
    H: ldec_H
    ndim: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_ldpc_decoder_def_0
  id: variable_ldpc_decoder_def
  parameters:
    file: /usr/share/gnuradio/fec/ldpc/n_1800_k_0902_gap_28.alist
    max_iter: '50'
    ndim: '0'
    sigma: '0.5'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: receive_freq
    orient: Qt.Horizontal
    start: 2.3999e9
    step: 0.00001e9
    stop: 2.40005e9
    value: 2.4e9
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0_0_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/opensourcesdr/Desktop/1.jftf
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/a
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: 185.18e3*4
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '0'
    mu: '0'
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.0628'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '0.01256'
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: variable_ldpc_decoder_def_0
    puncpat: '11'
    threadtype: none
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=813066dc27608ec7
    bb_gain0: '30'
    freq0: 2.4e9
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: 2e6
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: '"after loop"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: '"after cma"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: 2e6
    fc: 2.4e9
    fftsize: '1024'
    name: '"receive"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"after cma"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    name: '"last"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    name: '"after tag"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    name: '"after ldc decode"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    name: '"after qpsk"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: 2e6
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: ' demodel'
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ' demodel'
  states: {}

connections:
- [blocks_char_to_float_0, '0', fec_extended_decoder_0, '0']
- [blocks_char_to_float_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0_1_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_1_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_1_0_0_1, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0_1_0_0_2, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_float_to_char_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_char_0, '0']
- [blocks_multiply_const_vxx_1, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_0_1_0_0_2, '0']
- [blocks_repack_bits_bb_0, '0', virtual_sink_0_1, '0']
- [blocks_throttle_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_char_to_float_0_1_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_1, '0']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_cma_equalizer_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_cma_equalizer_cc_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_char_to_float_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_char_to_float_0_1_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_cma_equalizer_cc_0, '0']
- [fec_extended_decoder_0, '0', blocks_char_to_float_0_1_0_0_1, '0']
- [fec_extended_decoder_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_1, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_1, '0']
- [virtual_source_1, '0', blocks_char_to_float_0_1, '0']

metadata:
  file_format: 1
